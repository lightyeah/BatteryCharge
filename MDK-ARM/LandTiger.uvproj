# Keil uVision project LandTiger.uvproj, settings and files
target open1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ucos-ucdemo +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\Core\CM3\CoreSupport;..\..\..\Core\CM3\DeviceSupport\NXP\LPC17xx;..\USER;..\USER\ucCos_App;..\USER\uCOS-VIEW;..\USER\uCOS-II;..\USER\uC-CPU;..\USER\GLCD;..\USER\TouchPanel;..\USER\uCGUI;..\USER\uCGUI\Config;..\USER\uCGUI\inc;..\..\..\Drivers\include\.;..\Libraries\CM3\CoreSupport;..\Libraries\CM3\DeviceSupport\NXP\LPC17xx\startup\arm;..\Libraries\CM3\DeviceSupport;..\Libraries\CM3\DeviceSupport\NXP\LPC17xx;..\Libraries\LCP1768_StdPeriph_Driver\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group User
    ../USER/: main.c
    ../USER/ucCos_App/: uctsk_Task.c app_cfg.h includes.h
  group TouchPanel
    ../USER/TouchPanel/: TouchPanel.c
  group CMSIS
    ../Libraries/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
  group Startup
    ../Libraries/CM3/DeviceSupport/NXP/LPC17xx/startup/arm/: startup_LPC17xx.s
  group uC-OS-II/Port
    ../USER/uCOS-II/Ports/ARM-Cortex-M3/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC-OS-II/Source
    ../USER/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC-OS-II/Config
    ../USER/ucCos_App/: OS_AppHooks.c os_cfg.h
  group uCOS-Ⅱ/GUI_X
    ../USER/uCGUI/: GUI_X_Touch.c GUI_X_uCOS.c
  group uCGUI/GLCD
    ../USER/GLCD/: GLCD_UCGUI.c GLCD.c
  group uCGUI/Config
    ../USER/uCGUI/Config/: GUIConf.h GUITouchConf.h LCDConf.h
  group uCGUI/Demo
    ../USER/uCGUI/uCGUIDemo/: GUIDEMO.c GUIDEMO_Automotive.c GUIDEMO_Bitmap4bpp.c GUIDEMO_Bitmap.c GUIDEMO_Circle.c GUIDEMO_ColorBar.c GUIDEMO_ColorList.c GUIDEMO_Cursor.c GUIDEMO_Dialog.c GUIDEMO_Font.c GUIDEMO_FrameWin.c GUIDEMO_Graph.c GUIDEMO_HardwareInfo.c GUIDEMO_Intro.c GUIDEMO_LUT.c GUIDEMO_MemDevB.c GUIDEMO_Messagebox.c GUIDEMO_Navi.c GUIDEMO_Polygon.c GUIDEMO_ProgBar.c GUIDEMO_Speed.c GUIDEMO_Touch.c GUIDEMO_WM.c MainTask.c MicriumLogo.c MicriumLogoWRed.c
  group uCGUI/Lib
    ../uCGUI_LIB/: uCGUI.lib
  group Doc
    ../: readme.txt
  group driver
    ../Libraries/LCP1768_StdPeriph_Driver/source/: debug_frmwrk.c lpc17xx_adc.c lpc17xx_can.c lpc17xx_clkpwr.c lpc17xx_dac.c lpc17xx_emac.c lpc17xx_exti.c lpc17xx_gpdma.c lpc17xx_gpio.c lpc17xx_i2c.c lpc17xx_i2s.c lpc17xx_libcfg_default.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_pwm.c lpc17xx_qei.c lpc17xx_rit.c lpc17xx_rtc.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_wdt.c
  group RIT
    ../USER/RIT/: rit_test.c rit_test.h
